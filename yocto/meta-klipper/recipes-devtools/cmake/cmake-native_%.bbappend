CMAKE_EXTRACONF += "-DCMAKE_USE_SYSTEM_LIBRARIES=0"
