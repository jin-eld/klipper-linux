# otherwise util-linux-native fails to find magic.h on Centos 8
DEPENDS += "file"
