inherit setuptools
require python-numpy.inc

